# Keil uVision project TSU_V1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: S32K144HRxxxLLx NXP
  pack: Keil.S32_SDK_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TSU_V1 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\devices;..\devices\common;..\devices\S32K144;..\devices\S32K144\include;..\devices\S32K144\startup;..\user;..\drivers\src\clock\S32K1xx;..\drivers\inc;..\drivers\src\pins;..\drivers\src\lpuart;..\pal\osif;..\user;..\drivers\src\edma;..\drivers\src\lpi2c;..\drivers\src\flexcan
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: .\RTE\Device\S32K144HFxxxLLx\S32K144_64_flash.sct
  group USER
    ../user/: main.c s32k.c timer.c
    ../devices/: startup.c
    ../devices/S32K144/startup/: system_S32K144.c
    ../devices/S32K144/startup/arm/: startup_S32K144.s
  group SRC
    ../drivers/src/clock/: clock_manager.c
    ../drivers/src/clock/S32K1xx/: clock_S32K1xx.c
    ../drivers/src/interrupt/: interrupt_manager.c
    ../drivers/src/pins/: pins_driver.c pins_port_hw_access.c
    ../drivers/src/lpuart/: lpuart_driver.c lpuart_hw_access.c lpuart_irq.c
    ../pal/osif/: osif_baremetal.c
    ../drivers/src/edma/: edma_driver.c edma_hw_access.c edma_irq.c
    ../drivers/src/lpi2c/: lpi2c_driver.c lpi2c_hw_access.c lpi2c_irq.c
    ../drivers/src/flexcan/: flexcan_driver.c flexcan_hw_access.c flexcan_irq.c
  group Hareware
    ../user/: clockMan1.c pin_mux.c uart.c lpi2c1.c I2C.c Androidcom.c canCom1.c dmaController1.c Cpu.c fly_can.c TBT.c
software components: CMSIS:CORE 5.1.2
